# Keil uVision project project.uvprojx, settings and files
target rtthread (6140000::V6.14::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER, STM32F411xE
  c include: .;rt-thread\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\drv_flash;packages\crclib-latest\inc;packages\EV-latest\attitude;.;packages\EV-latest\control_unit;.;packages\EV-latest\core;.;packages\EV-latest\evt;.;packages\EV-latest\imu;.;packages\EV-latest\indicator;.;packages\EV-latest\library\ano;.;packages\EV-latest\monitor;.;packages\EV-latest\motor;.;packages\EV-latest\power;.;packages\EV-latest\rc;.;packages\EV-latest\status;.;packages\fal-latest\inc;packages\fastlz-latest;packages\ota_downloader-latest;packages\qboot-latest\inc;packages\quicklz-latest;packages\quick_led-latest\inc;packages\tinycrypt-latest\include;packages\zlib-latest\inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\common;rt-thread\components\utilities\ymodem;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: ads1118.c board_init.c key.c lm75.c smoke_sensor.c spi_flash_init.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_common.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group crclib
    packages/crclib-latest/src/: crc16.c crc32.c crc8.c
  group ev
    packages/EV-latest/attitude/: ev_attitude.c
    packages/EV-latest/control_unit/: ev_cu_bcar.c
    packages/EV-latest/core/: ev.c pss.c
    packages/EV-latest/evt/: cmd_cu_bcar.c cmd_motor.c cmd_status.c cmd_template.c evt.c
    packages/EV-latest/imu/: ev_imu.c
    packages/EV-latest/indicator/: ev_indicator_led.c
    packages/EV-latest/library/ano/: ano.c
    packages/EV-latest/monitor/: ev_monitor_bc.c
    packages/EV-latest/motor/: ev_motor.c ev_motor_speed.c
    packages/EV-latest/power/: ev_power.c
    packages/EV-latest/rc/: ev_rc.c
    packages/EV-latest/status/: ev_status.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-latest/samples/porting/: fal_flash_sfud_port.c
  group fastlz
    packages/fastlz-latest/: fastlz.c
  group ota_downloader
    packages/ota_downloader-latest/src/: ymodem_ota.c
  group qboot
    packages/qboot-latest/src/: qboot.c qboot_aes.c qboot_at32.c qboot_fastlz.c qboot_gzip.c qboot_quicklz.c qboot_stm32.c
  group quicklz
    packages/quicklz-latest/: quicklz.c
  group quick_led
    packages/quick_led-latest/src/: qled.c qled_sample.c
  group TinyCrypt
    packages/tinycrypt-latest/src/: tiny_aes.c tiny_base64.c tiny_md5.c tiny_sha1.c tiny_sha2.c
  group zlib
    packages/zlib-latest/src/: adler32.c compress.c crc32.c deflate.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group Utilities
    rt-thread/components/utilities/ymodem/: ymodem.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
